# IAR project stm32_shell.ewp, settings and files
configuration stm32_shell (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; PKG_MODBUS_SLAVE_RTU
  ICCARM.CCIncludePath2: ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Core/Inc; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../User/app/Canopen/CanFestival-3/include; ../User/app/Canopen/CanFestival-3/include/STM32; ../App/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../User/common; ../User/Dev; ../User/bsp; ../User/Components; ..\Middlewares\Third_Party\FatFs\src\option; ..\User\app\sramfatfs; ../User/bsp/w25qxx; ../User/app/freemodbus/modbus/include; ../User/app/freemodbus/port; ../User/app/freemodbus/modbus/rtu
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: stm32_shell.hex
  ILINK.IlinkOutputFile: stm32_shell.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User/app/canopen
    ../User/app/canopen/: can_master.c
  group Application/User/app/canopen/CanFestival-3/include
    ../User/app/canopen/CanFestival-3/include/: can.h can_driver.h data.h dcf.h def.h emcy.h lifegrd.h lss.h nmtMaster.h nmtSlave.h objacces.h ObjDict.h objdictdef.h pdo.h sdo.h states.h sync.h sysdep.h timer.h timers_driver.h
  group Application/User/app/canopen/CanFestival-3/src
    ../User/app/canopen/CanFestival-3/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c symbols.c sync.c timer.c
  group Application/User/app/canopen/common
    ../User/app/canopen/common/: can_common_api.c can_common_api.h can_thread.c can_thread.h CANOpenObjDictConfig.c CANOpenObjDictConfig.h timer_thread.c timer_thread.h
  group Application/User/app/canopen/master402
    ../User/app/canopen/master402/: canopen_callback.c canopen_callback.h master402_canopen.c master402_canopen.h motor_control.c
  group Application/User/app/canopen/ptz_horiz
    ../User/app/canopen/master402/: master402_od.c master402_od.h
    ../User/app/canopen/ptz_horiz/: ptz_horiz_motion_control.c ptz_horiz_motion_control.h ptz_horiz_objdict.c ptz_horiz_objdict.h
  group Application/User/app/cpp_test
    ../User/app/cpp_test/: test.cpp test.h test.hpp testadd.c testadd.h
  group Application/User/app/FreeModbus
    ../User/app/freemodbus/modbus/: mb.c
    ../User/app/freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../User/app/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../User/app/freemodbus/: mobus_slave.c
    ../User/app/freemodbus/port/: port_.c port_.h portevent.c portother.c portserial.c porttimer.c user_mb_app.c
  group Application/User/app/shell
    ../User/app/shell/: shell.c shell.h shell_cmd.c shell_cmd.h
  group Application/User/bsp
    ../User/bsp/: bsp.c bsp.h bsp_isr_def.h can_bsp.c can_bsp.h spi_bsp.c spi_bsp.h sram_bsp.c sram_bsp.h time_bsp.c time_bsp.h uart_bsp.c uart_bsp.h uart_dev.c uart_dev.h
  group Application/User/bsp/w25qxx
    ../User/bsp/w25qxx/: w25qxx.c w25qxx.h
  group Application/User/common
    ../User/common/: usrapi.h usrdef.h
  group Application/User/Components
    ../User/Components/: dlist.h ring_buffer.c ring_buffer.h
    ../User/app/shell/: getopt.c getopt.h
  group Application/User/Core
    ../Core/Src/: can.c freertos.c fsmc.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c
  group EWARM
    ./: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
